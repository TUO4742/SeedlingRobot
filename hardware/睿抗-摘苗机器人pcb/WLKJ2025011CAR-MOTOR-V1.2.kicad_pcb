# Repository TUO4742/SeedlingRobot

File README.md:

# ROS2 自动夹苗机器人

一套面向**自动取苗 → 运输 → 放苗**作业的全栈移动机器人：从机械结构、自制 PCB、STM32/FreeRTOS 固件，
到 ROS2 导航与定位，全部由本人完成。

> 起源于 **2026 睿抗机器人开发者大赛（CAIR 工程竞技赛道）**，赛后将工程整理为可复现的开源版本。

**演示视频**：[`docs/media/automatic-seedling-clamping-demo.mp4`](docs/media/automatic-seedling-clamping-demo.mp4)

---

## 1. 这套系统能做什么

| 能力 | 实现位置 | 状态 |
| --- | --- | --- |
| 麦克纳姆四轮全向移动（前后 / 横移 / 斜行 / 原地旋转） | `firmware/stm32/Robot/chassis_task.c` | 实机验证 |
| 四路编码器测速 + 增量式 PID 闭环 | `firmware/stm32/Headware/encoder.c` | 实机验证 |
| 四舵机取苗 / 夹苗 / 放苗姿态与缓动 | `firmware/stm32/Robot/arm_control.c` | 实机验证 |
| PS2 手柄遥控 + 组合键机械臂点动 | `firmware/stm32/Headware/ps2_usart5.c` | 实机验证 |
| 300 ms 失联停车、短刹、模式互锁、回中解锁 | `firmware/stm32/Robot/chassis_task.c` | 实机验证 |
| ROS2 导航（AMCL + NavFn + MPPI 全向） | `ros2_ws/` | **代码完成，待实机联调** |

---

## 2. 系统架构

```text
        ┌──────────────────────────────┐
        │  ROS2 (Ubuntu / RDK)          │
        │  chassis_node → /odom → EKF   │
        │  Nav2: AMCL + NavFn + MPPI    │
        └──────────────┬───────────────┘
                       │ UART 14B 下行 / 22B 上行
                       ▼
        ┌──────────────────────────────┐
        │  STM32F103RCT6 + FreeRTOS     │
        │  ┌────────────┬─────────────┐ │
        │  │ 底盘控制    │ 机械臂/舵机  │ │
        │  │ 逆解 + PID  │ 姿态 + 缓动  │ │
        │  └────────────┴─────────────┘ │
        │  安全：失联停车 / 模式互锁      │
        └──────────────┬───────────────┘
                       ▼
            TB6612 ×2 · 编码器 ×4 · 舵机 ×4
```

---

## 3. 实时软件（如实说明）

固件里只有 **2 个 FreeRTOS 任务**：

| 任务 | 优先级 | 栈 | 周期 | 作用 |
| --- | --- | ---: | --- | --- |
| `defaultTask` | Normal | 512 B | 1 ms | CubeMX 生成的占位空任务 |
| `chassisTask` | High | 4 KB | 20 ms | **唯一的业务主循环** |

`chassisTask` 在单个循环里串行完成：手柄帧解析 → 三级安全互锁 → 机械臂输入 → 麦轮逆解 → 编码器闭环 → 舵机输出。

**刻意不使用队列 / 信号量 / 互斥量**，中断与任务之间用 `volatile` 标志 + 单行双缓冲 + `__disable_irq` 临界区通信。
理由是控制链路本身是严格顺序的，引入跨任务 IPC 只会增加调度抖动，对 20 ms 周期没有收益。

> 真正的时间基准由 **TIM6 中断（50 Hz）** 提供，`vTaskDelayUntil` 保证任务周期无累积漂移。

---

## 4. 底盘运动学

轮序 **0=FL, 1=RR, 2=RL, 3=FR**（物理接线 remap 后的顺序，不是 FL/FR/RL/RR），
`K = L + W = 0.168 m`，轮径 `0.065 m`。

**逆解**（`chassis_task.c`）

```text
FL = vx - vy - K·wz      RR = vx - vy + K·wz
RL = vx + vy - K·wz      FR = vx + vy + K·wz
```

**正解**（`encoder.c`）

```text
vx = ( FL + RR + RL + FR) / 4
vy = (-FL - RR + RL + FR) / 4
wz = (-FL + RR - RL + FR) / (4K)
```

两个方向**严格互逆**，已验证误差 < 1e-15（见第 8 节自检工具）。

---

## 5. 执行机构

定时器资源受限，四路舵机用两种方式驱动：

- **CH1 / CH2**：硬件 PWM（PA0 / PA1）
- **CH3 / CH4**：比较中断 + GPIO 软件翻转（PC5 / PB0）

时基统一为 **TIM5 @ 1 MHz，周期 20 ms（50 Hz）**，脉宽 `500 + angle × 2000 / 180 µs`，
限幅 0–180°，缓动步进 2°/20 ms（约 100 °/s）。

---

## 6. ROS2 导航栈

`ros2_ws/` 是按本机实际参数重写的，**不是从别的项目复制**。详见
[`ros2_ws/README.md`](ros2_ws/README.md) 与 [`docs/ROS2导航设计与验证.md`](docs/ROS2导航设计与验证.md)。

| 环节 | 选型 |
| --- | --- |
| 底盘桥接 | 自研 `seedling_chassis`（C++，50 Hz） |
| 里程计 | 四轮编码器正解 → 积分 → `/odom` |
| 融合 | `robot_localization` EKF（无 IMU，仅轮速） |
| 定位 | AMCL **`OmniMotionModel`**（麦轮必须） |
| 规划 | NavFn / Dijkstra |
| 控制 | `RotationShim` + MPPI **`motion_model: Omni`** |
| 限速 | `vx 0.35 / vy 0.30 / wz 0.80` |

两个麦轮专属坑已避开：

1. AMCL 不用 `OmniMotionModel` → 横移会被当成噪声；
2. `velocity_smoother.max_velocity` 第二项留空 → 横移在输出前被截成 0。

---

## 7. 仓库结构

```text
firmware/stm32/     STM32F103RCT6 + FreeRTOS 固件（Keil MDK）
  Robot/            底盘任务、机械臂状态机、麦轮逆解
  Headware/         电机 / 编码器 / 舵机 / PS2 / I2C 驱动
  Doc/              接线说明、ROS2 接口说明
ros2_ws/            ROS2 导航栈（底盘桥接 + Nav2 参数 + URDF）
hardware/           自制控制板 KiCad 工程
mechanical/         四自由度平行夹爪与整车的 STEP / STL / DXF
docs/               媒体素材与设计文档
```

---

## 8. 快速开始

### 8.1 固件

```text
1. Keil MDK 打开 firmware/stm32/MDK-ARM/1_template_led.uvprojx
2. 确认时钟 72 MHz、TIM5 舵机时基、TIM2 PWM、编码器定时器
3. 编译并烧录 STM32F103RCT6
4. 上电前核对：电机方向、舵机零位、急停、通信波特率
```

### 8.2 ROS2

```bash
cd ros2_ws
source /opt/ros/humble/setup.bash
colcon build --symlink-install
source install/setup.bash

# 建图
ros2 launch seedling_bringup slam.launch.py

# 导航（需先有地图）
ros2 launch seedling_bringup nav2.launch.py map:=/path/to/map.yaml
```

> 接入导航前需要给固件补一组二进制串口帧，见
> [`firmware/stm32/Doc/ROS2接口说明.md`](firmware/stm32/Doc/ROS2接口说明.md)。

### 8.3 自检（无需硬件）

```bash
python3 ros2_ws/tools/kinematics_check.py    # 正解/逆解闭环、符号语义、分辨率
python3 ros2_ws/tools/protocol_selftest.py   # 14B/22B 帧编解码与校验
```

两者均为纯 Python，无第三方依赖，退出码 0 表示通过。

---

## 9. 已知限制

- **ROS2 导航尚未实机跑通**：代码完成并通过静态校验，固件侧接口未实现。
- **无 IMU**：航向完全依赖四轮正解，打滑会导致 yaw 漂移。
- **低速量化**：1320 counts/转，20 ms 采样下 1 个计数 = 7.7 mm/s，低于约 8 mm/s 时速度分辨率明显。
- **麦轮横移效率低**：`vy_max` 已收敛到 0.30 m/s，不要盲目调高。
- **无看门狗**：`stm32f1xx_hal_conf.h` 中 IWDG/WWDG 宏被注释，长期无人值守运行需自行补上。
- **无 HardFault 现场保存**：四个 fault handler 均为空 `while(1)`。

---

## 10. 路线图

- [ ] 固件实现 `ros_bridge.c`，打通 14/22 字节串口协议
- [ ] 实机验证 `/odom` 尺度与 AMCL 定位精度
- [ ] 补 IWDG 与 HardFault 寄存器快照
- [ ] 用 EKF + 轮速做里程计标定表（替代单一轮径）
- [ ] 加装 IMU（WT9011G4K）后启用 `imu0` 融合

---

## 11. 许可

本项目自研代码采用 **MIT License**，见 [LICENSE](LICENSE)。

仓库中的 `Drivers/`（ST HAL + CMSIS）与 `Middlewares/`（FreeRTOS）为第三方组件，
遵循其原始许可条款，不受本项目 MIT 许可覆盖。

---

## English Summary

A full-stack ROS2 mecanum mobile robot for automatic seedling clamping: mechanical design, custom PCB,
STM32/FreeRTOS firmware (20 ms control loop, 4-wheel incremental PID, 4-servo actuation, lost-link safety),
and a ROS2 navigation stack (encoder odometry → robot_localization EKF → AMCL `OmniMotionModel` → NavFn → MPPI `Omni`).
Kinematics and the serial protocol ship with self-checking scripts. Firmware is field-proven;
the ROS2 navigation layer is implemented and statically verified but not yet validated on hardware.

## KiCad design hardware/睿抗-摘苗机器人pcb/WLKJ2025011CAR-MOTOR-V1.2.kicad_pcb

Parts:
BZ1: QMB-09B-03/D9mmH5.5mm; Buzzer_D9_H5.5_P5
C1, C18, C23: 100uF/25V/D6.3xL7; CP_Radial_D6.3mm_P2.50mm
C2, C3, C4, C9, C11, C12, C17, C19, C24, C26, C27: 100nF/50V/0603; C_0603_1608Metric
C5, C6, C13, C14: 10uF/50V/1206; C_1206_3216Metric
C7, C8, C15, C16: 22uF/25V/1206; C_1206_3216Metric
C10, C22, C31: 2.2uF/25V/0603; C_0603_1608Metric
C20, C21, C29, C30: 10uF/10V/0603; C_0603_1608Metric
C25, C28: 1uF/25V/0603; C_0603_1608Metric
D1: 1N5819WS/SOD323; D_SOD-323_HandSoldering
D2, D3, D4: 翠绿色/0603; LED_0603_1608Metric
D5: SMAJ12A/SMA; D_SMA
H1, H2, H3, H4: M2.5; MountingHole_2.7mm_M2.5; not fitted
J1, J2, J3, J4: PH2.0/6PIN/直插; JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical
J5: KF301-5.0-2P/P5.0mm; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J6: DC-044A-A200; BarrelJack_CUI_PJ-079BH_Horizontal
J7, J8: 2.54排母/22PIN/直插; PinSocket_1x22_P2.54mm_Vertical
J9, J11, J12, J14, J15, J16: 2.54排针/3PIN/直插; PinHeader_1x03_P2.54mm_Vertical
J10, J13: XH2.54/4PIN/直插; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J17: USBA/10.0 QHHTZB6.3; USB_A_TH_10x6.8mm_Horizontal
J18: 2.54排针/2x4PIN/直插; PinHeader_2x04_P2.54mm_Vertical
J19: TYPE-C16PIN/卧插; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
L1, L2: 5.6uH/6A/0630/FXL0630-5R6-M; L_Changjiang_FXL0630
Q1: 2N7002/SOT23-3; SOT-23
Q2: NCEP3040Q/DFN8-3.3x3.3; VSON-8_3.3x3.3mm_P0.65mm_NexFET
R1, R4, R6, R9, R10, R11, R16: 10K/1%/0603; R_0603_1608Metric
R2, R14, R18: 1K/1%/0603; R_0603_1608Metric
R3, R7, R17, R20: 100K/1%/0603; R_0603_1608Metric
R5: 8.66K/1%/0603; R_0603_1608Metric
R8: 13K/1%/0603; R_0603_1608Metric
R12, R13, R15: 4.7K/1%/0603; R_0603_1608Metric
R19: 0.01R/1%/1W/W1206; R_1206_3216Metric
SW1: SK-22F02-G060; SK-22F02
SW2, SW3: KH-6X6X5H-STM; SW_PUSH_6x6
U1, U3: SY8286ARAC/QFN20-3x3; QFN-20-1EP_3x3mm_P0.45mm_EP1.6x1.6mm
U2, U5: TB6612FNG/SSOP-24; SSOP-24_5.3x8.2mm_P0.65mm
U4: ME6206A33XG/SOT23-3; TSOT-23
U6: CH559T/SSOP-20; SSOP-20_5.3x7.2mm_P0.65mm
U7: W25Q32JVSSIQ/SOP-8; SOIC-8_5.23x5.23mm_P1.27mm
U8: IP2723T/QFN24-4x4; QFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm

Connections:
3.3V: C20.2, C26.1, J8.21, R16.1, U4.2 (VOUT), U7.3 (IO2), U7.7 (IO3), U7.8 (VCC)
5V: BZ1.1 (+), C2.2, C15.2, C16.2, C17.2, C19.2, C21.2, C27.2, C28.2, C30.1, D1.1 (K), J1.2, J2.2, J3.2, J4.2, J7.22, J10.4, J13.3, J17.1 (VBUS), J18.1, J18.3, J18.5, J18.7, L2.2, Q2.5 (D), R7.1, R13.1, R15.2, U2.20 (VCC), U4.3 (VIN), U5.20 (VCC), U6.19 (VIN5), U8.24 (VIN)
7.4V: C7.2, C8.2, C9.2, C23.1, J9.2, J11.2, J12.2, J14.2, J15.2, J16.2, L1.2, R3.1
/5V_PG: D3.2 (A), R9.1, U3.9 (PG)
/7.4V_PG: D4.2 (A), R10.1, U1.9 (PG)
/ADC_BAT: C24.2, J7.14, R12.1, R14.2
/BUZZER: J8.19, R2.2
/CH559_DM: J17.2 (D-), U6.15 (P5.0)
/CH559_DP: J17.3 (D+), U6.14 (P5.1)
/CSP1: J19.A1 (GND), J19.A12 (GND), J19.B1 (GND), J19.B12 (GND), J19.S1 (SHIELD), R19.1, U8.11 (CSP1)
/MCU_I2C1_SCL: J7.16, J13.2, R15.1
/MCU_I2C1_SDA: J7.15, J13.1, R13.2
/MCU_RST: J7.17, SW2.2
/MCU_UART2_RX: J8.14, J10.1
/MCU_UART2_TX: J8.13, J10.2
/MCU_UART5_RX: J8.12, U6.16 (P0.3)
/PB0: J7.19, J14.1
/PB1: J7.20, J15.1
/PB2: J7.21, J16.1
/PC4: J8.20, R16.2, SW3.2
/PC5: J7.18, J12.1
/SPI1_MISO: J8.16, U7.2 (DO(IO1))
/SPI1_MOSI: J8.15, U7.5 (DI(IO0))
/SPI1_SCK: J8.17, U7.6 (CLK)
/SPI1_SS: J8.18, U7.1 (~CS)
/TB6612_1_AIN1: J7.5, U2.21 (AIN1)
/TB6612_1_AIN2: J7.4, U2.22 (AIN2)
/TB6612_1_AO1: J1.6, U2.1 (AO1), U2.2 (AO1)
/TB6612_1_AO2: J1.1, U2.5 (AO2), U2.6 (AO2)
/TB6612_1_BIN1: J7.7, U2.17 (BIN1)
/TB6612_1_BIN2: J7.8, U2.16 (BIN2)
/TB6612_1_BO1: J2.6, U2.11 (BO1), U2.12 (BO1)
/TB6612_1_BO2: J2.1, U2.7 (BO2), U2.8 (BO2)
/TB6612_1_STBY: J7.6, U2.19 (STBY)
/TB6612_2_AIN1: J8.7, U5.21 (AIN1)
/TB6612_2_AIN2: J8.8, U5.22 (AIN2)
/TB6612_2_AO1: J3.6, U5.1 (AO1), U5.2 (AO1)
/TB6612_2_AO2: J3.1, U5.5 (AO2), U5.6 (AO2)
/TB6612_2_BIN1: J8.5, U5.17 (BIN1)
/TB6612_2_BIN2: J8.4, U5.16 (BIN2)
/TB6612_2_BO1: J4.6, U5.11 (BO1), U5.12 (BO1)
/TB6612_2_BO2: J4.1, U5.7 (BO2), U5.8 (BO2)
/TB6612_2_STBY: J8.6, U5.19 (STBY)
/TIM1_ENCODER_CH1: J4.3, J8.2
/TIM1_ENCODER_CH2: J4.4, J8.1
/TIM2_PWM_CH1: J7.3, U2.23 (PWMA)
/TIM2_PWM_CH2: J7.9, U2.15 (PWMB)
/TIM2_PWM_CH3: J8.3, U5.15 (PWMB)
/TIM2_PWM_CH4: J8.9, U5.23 (PWMA)
/TIM3_ENCODER_CH1: J1.3, J7.1
/TIM3_ENCODER_CH2: J1.4, J7.2
/TIM4_ENCODER_CH1: J2.3, J7.10
/TIM4_ENCODER_CH2: J2.4, J7.11
/TIM5_PWM_CH1: J7.12, J9.1
/TIM5_PWM_CH2: J7.13, J11.1
/TIM8_ENCODER_CH1: J3.3, J8.11
/TIM8_ENCODER_CH2: J3.4, J8.10
GND: C1.2, C2.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.2, C19.1, C20.1, C21.1, C22.1, C23.2, C24.1, C25.2, C26.2, C27.1, C28.1, C29.1, C30.2, C31.2, D3.1 (K), D4.1 (K), D5.2 (A2), J1.5, J2.5, J3.5, J4.5, J5.2, J6.2, J6.3, J6.MP (MountPin), J8.22, J9.3, J10.3, J11.3, J12.3, J13.4, J14.3, J15.3, J16.3, J17.4 (GND), J17.5 (Shield), J18.2, J18.4, J18.6, J18.8, Q1.2 (E), R4.1, R5.2, R8.2, R11.1, R14.1, R18.2, R19.2, R20.1, SW1.MP, SW2.1, SW3.1, U1.7 (GND), U1.8 (GND), U1.12 (MODE), U1.13 (ILMT), U1.18 (GND), U1.21 (EP), U2.3 (PGND1), U2.4 (PGND1), U2.9 (PGND2), U2.10 (PGND2), U2.18 (GND), U3.7 (GND), U3.8 (GND), U3.12 (MODE), U3.13 (ILMT), U3.18 (GND), U3.21 (EP), U4.1 (VSS), U5.3 (PGND1), U5.4 (PGND1), U5.9 (PGND2), U5.10 (PGND2), U5.18 (GND), U6.18 (VSS), U7.4 (GND), U8.8 (CSP2), U8.9 (CSN2), U8.10 (CSN1), U8.18 (GND), U8.25 (EP)
unnamed: BZ1.2 (-), D1.2 (A), Q1.3 (C)
unnamed: C3.2, L1.1, U1.6 (LX), U1.19 (LX), U1.20 (LX)
unnamed: C11.2, L2.1, U3.6 (LX), U3.19 (LX), U3.20 (LX)
unnamed: D2.1 (K), R11.2
unnamed: J5.1, J6.1, SW1.2 (B), SW1.5 (B)
unnamed: J19.A5 (CC1), U8.17 (CC1)
unnamed: J19.B5 (CC2), U8.14 (CC2)
unnamed: Q1.1 (B), R2.1, R4.2
unnamed: Q2.4 (G), R17.2, U8.23 (VOUT1G)
unnamed: C3.1, U1.1 (BS)
unnamed: R1.1, U1.11 (EN)
unnamed: R3.2, R5.1, U1.14 (FB)
unnamed: C10.2, U1.17 (VCC)
unnamed: C11.1, U3.1 (BS)
unnamed: R6.1, U3.11 (EN)
unnamed: R7.2, R8.1, U3.14 (FB)
unnamed: C22.2, U3.17 (VCC)
unnamed: C25.1, U6.20 (VDD33)
unnamed: R18.1, U8.2 (CMPV)
unnamed: J19.A7 (D-), J19.B7 (D-), U8.16 (DM)
unnamed: J19.A6 (D+), J19.B6 (D+), U8.15 (DP)
unnamed: R20.2, U8.19 (NTC)
unnamed: C31.1, U8.1 (VCC)
VBAT_12.6: C1.1, C4.2, C5.2, C6.2, C12.2, C13.2, C14.2, C18.1, D2.2 (A), D5.1 (A1), R1.2, R6.2, R9.2, R10.2, R12.2, SW1.3 (C), SW1.4 (A), U1.2 (IN), U1.3 (IN), U1.4 (IN), U1.5 (IN), U2.13 (VM2), U2.14 (VM3), U2.24 (VM1), U3.2 (IN), U3.3 (IN), U3.4 (IN), U3.5 (IN), U5.13 (VM2), U5.14 (VM3), U5.24 (VM1)
VOUT_5V: C29.2, J19.A4 (VBUS), J19.A9 (VBUS), J19.B4 (VBUS), J19.B9 (VBUS), Q2.1 (S), Q2.2 (S), Q2.3 (S), R17.1, U8.22 (VOUT1)

Notes on the sheet:
FLASH
蜂鸣器
电机接口
PWM舵机接口
3.3V电源
拓展接口
PS2手柄接口
电压检测
核心板接口
树莓派供电协议芯片
电源接口
舵机供电
电机驱动
树莓派供电
电源指示灯

Board: 4 copper layers, 85.0 x 56.0 mm, 95 parts (0 on the bottom side), 83 nets.

## Code that names these connections

File firmware/stm32/Robot/robot_config.h:

#ifndef __ROBOT_CONFIG_H
#define __ROBOT_CONFIG_H

/*
 * RuiKang v1.4 user configuration.
 *
 * Coordinate convention:
 *   +vx: robot forward
 *   +vy: robot left
 *   +wz: counter-clockwise viewed from above
 *
 * The values in this file are intentionally centralized so that joystick
 * direction, speed and arm poses can be calibrated without editing drivers.
 */

/* ---------------- PS2 / chassis ---------------- */
#define ROBOT_CONTROL_PERIOD_MS          (20U)
#define PS2_LINK_TIMEOUT_MS              (300U)
#define PS2_AXIS_DEADZONE                (12)

/* Raw USB-HID axes are centered at 0x80. Up/left are normally negative. */
#define PS2_LEFT_Y_TO_FORWARD_SIGN       (-1.0f)
#define PS2_LEFT_X_TO_LEFT_SIGN          (-1.0f)
/* Set to -1 only if the CH559 X/B yaw direction is reversed on the robot. */
#define PS2_RIGHT_CONTROL_TO_CCW_SIGN    (1.0f)

#define CHASSIS_MAX_VX_MPS               (0.6f)
#define CHASSIS_MAX_VY_MPS               (0.5f)
#define CHASSIS_MAX_WZ_RADPS             (3.50f)

/* L + W for mecanum inverse kinematics, in metres. */
#define CHASSIS_WHEEL_BASE_SUM_M         (0.168f)
#define CHASSIS_MAX_WHEEL_SPEED_MPS      (0.72f)
#define CHASSIS_TARGET_STEP_MPS          (0.020f)

/* Encoder sign for each motor: +1 or -1, depending on physical wiring.
 * Physical wheel index after rewiring: 0=FL, 1=RR, 2=RL, 3=FR.
 * The lifted-wheel test showed RL (2) and FR (3) require reversed signs. */
#define MOTOR_ENCODER_DIR_0             (1)
#define MOTOR_ENCODER_DIR_1             (1)
#define MOTOR_ENCODER_DIR_2             (-1)
#define MOTOR_ENCODER_DIR_3             (-1)

/* Motor output sign for physical wheel index 0=FL, 1=RR, 2=RL, 3=FR. */
#define MOTOR_OUTPUT_DIR_0              (1)
#define MOTOR_OUTPUT_DIR_1              (1)
#define MOTOR_OUTPUT_DIR_2              (-1)
#define MOTOR_OUTPUT_DIR_3              (-1)

/* Minimum motor PWM output to avoid exact-zero comparison noise. */
#define MOTOR_STOP_THRESHOLD            (3)

/* Verified differential-chassis gains; revalidate with the mecanum load. */
#define MOTOR_PID_KP                     (70.0f)
#define MOTOR_PID_KI                     (20.0f)
#define MOTOR_PID_KD                     (0.0f)
#define MOTOR_PID_MAX_OUT                (100.0f)

/* ---------------- Four-servo arm ----------------
 * Board connectors:
 *   Servo 1: J9  / PA0 / TIM5_CH1 hardware PWM
 *   Servo 2: J11 / PA1 / TIM5_CH2 hardware PWM
 *   Servo 3: J12 / PC5 (TIM5_CH3 compare-timed GPIO pulse)
 *   Servo 4: J14 / PB0 (TIM5_CH4 compare-timed GPIO pulse)
 *   J15/PB1 and J16/PB2 are intentionally left unused.
 */
#define ARM_SERVO_COUNT                  (4U)
#define ARM_SERVO_MIN_PULSE_US           (500U)
#define ARM_SERVO_MAX_PULSE_US           (2500U)

/* Set to 1 if a joint rotates opposite to the requested logical angle. */
#define ARM_SERVO1_REVERSED              (0U)
#define ARM_SERVO2_REVERSED              (0U)
#define ARM_SERVO3_REVERSED              (0U)
#define ARM_SERVO4_REVERSED              (0U)

/* Narrow these limits before the first powered mechanical test if needed. */
#define ARM_SERVO1_MIN_DEG               (0U)
#define ARM_SERVO1_MAX_DEG               (180U)
#define ARM_SERVO2_MIN_DEG               (0U)
#define ARM_SERVO2_MAX_DEG               (180U)
#define ARM_SERVO3_MIN_DEG               (0U)
#define ARM_SERVO3_MAX_DEG               (180U)
#define ARM_SERVO4_MIN_DEG               (0U)
#define ARM_SERVO4_MAX_DEG               (180U)

#define ARM_START_SERVO1_DEG             (175U)      //初始化机械臂姿态，180最下面
#define ARM_START_SERVO2_DEG             (35U)     //30最上面
#define ARM_START_SERVO3_DEG             (120U)     //30合住
#define ARM_START_SERVO4_DEG             (120U)     /* Same initial state as Servo 3. */

/* Maximum movement per control period. 2 deg / 20 ms = 100 deg/s. */
#define ARM_MOVE_STEP_DEG                (2U)

/* SELECT+shoulder manual jogging. Flip a sign if physical CW is reversed. */
#define ARM_MANUAL_JOG_STEP_DEG          (2U)
#define ARM_GRIPPER_JOG_STEP_DEG         (2U)
#define ARM_BIG_ARM_CW_SIGN              (1)
#define ARM_SMALL_ARM_CW_SIGN            (1)

/* Legacy fixed Servo 3 targets retained for calibration/reference. */
#define ARM_GRIPPER_OPEN_DEG             (105U)
#define ARM_GRIPPER_CLOSE_DEG            (140U)

/*
 * Four editable three-servo poses. These starting values come from the useful
 * approach/carry/plant/barn postures in the first-generation project. Adjust
 * only this table after confirming each joint's safe direction and limits.
 */
#define ARM_POSE_L1_SERVO1_DEG           (115U)    //上下左右
#define ARM_POSE_L1_SERVO2_DEG           (95U)    //放置幼苗动作
#define ARM_POSE_L1_SERVO3_DEG           (0U)                   
#define ARM_POSE_L1_SERVO4_DEG           (0U)
                                                                 
#define ARM_POSE_L2_SERVO1_DEG           (175U)     //采集幼苗动作
#define ARM_POSE_L2_SERVO2_DEG           (35U)
#define ARM_POSE_L2_SERVO3_DEG           (120U)
#define ARM_POSE_L2_SERVO4_DEG           (120U)

#define ARM_POSE_R1_SERVO1_DEG           (175U)
#define ARM_POSE_R1_SERVO2_DEG           (35U)
#define ARM_POSE_R1_SERVO3_DEG           (0U)
#define ARM_POSE_R1_SERVO4_DEG           (0U)

#define ARM_POSE_R2_SERVO1_DEG           (130U)
#define ARM_POSE_R2_SERVO2_DEG           (90U)
#define ARM_POSE_R2_SERVO3_DEG           (120U)
#define ARM_POSE_R2_SERVO4_DEG           (120U)

#if (ARM_SERVO_MIN_PULSE_US >= ARM_SERVO_MAX_PULSE_US)
#error "Servo minimum pulse must be below the maximum pulse"
#endif

#if (ARM_SERVO_MAX_PULSE_US >= 20000U)
#error "Servo pulse must be shorter than the fixed 20 ms TIM5 frame"
#endif

#if ((ARM_SERVO1_MIN_DEG > ARM_SERVO1_MAX_DEG) || \
     (ARM_SERVO2_MIN_DEG > ARM_SERVO2_MAX_DEG) || \
     (ARM_SERVO3_MIN_DEG > ARM_SERVO3_MAX_DEG) || \
     (ARM_SERVO4_MIN_DEG > ARM_SERVO4_MAX_DEG))
#error "Each servo minimum angle must be below its maximum angle"
#endif

#if ((ARM_SERVO1_MAX_DEG > 180U) || \
     (ARM_SERVO2_MAX_DEG > 180U) || \
     (ARM_SERVO3_MAX_DEG > 180U) || \
     (ARM_SERVO4_MAX_DEG > 180U))
#error "Servo logical angles must stay within 0..180 degrees"
#endif

#if (ARM_MOVE_STEP_DEG == 0U)
#error "ARM_MOVE_STEP_DEG must be non-zero"
#endif

#if (ARM_MANUAL_JOG_STEP_DEG == 0U)
#error "ARM_MANUAL_JOG_STEP_DEG must be non-zero"
#endif

#if (ARM_GRIPPER_JOG_STEP_DEG == 0U)
#error "ARM_GRIPPER_JOG_STEP_DEG must be non-zero"
#endif

#if (((ARM_BIG_ARM_CW_SIGN) != 1) && ((ARM_BIG_ARM_CW_SIGN) != -1))
#error "ARM_BIG_ARM_CW_SIGN must be +1 or -1"
#endif

#if (((ARM_SMALL_ARM_CW_SIGN) != 1) && ((ARM_SMALL_ARM_CW_SIGN) != -1))
#error "ARM_SMALL_ARM_CW_SIGN must be +1 or -1"
#endif

#if ((ARM_GRIPPER_OPEN_DEG < ARM_SERVO3_MIN_DEG) || \
     (ARM_GRIPPER_OPEN_DEG > ARM_SERVO3_MAX_DEG) || \
     (ARM_GRIPPER_CLOSE_DEG < ARM_SERVO3_MIN_DEG) || \
     (ARM_GRIPPER_CLOSE_DEG > ARM_SERVO3_MAX_DEG))
#error "Gripper open/close targets must stay inside Servo 3 limits"
#endif

#endif
